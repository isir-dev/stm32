# Keil uVision project Project.uvprojx, settings and files
target STM324xG_EVAL (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM324xG_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\lwip;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\netif;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\ipv4;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4x7;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4x7\FreeRTOS;..\..\..\..\Utilities\Third_Party\FreeRTOSV7.3.0\portable\RVDS\ARM_CM3;..\..\..\..\Utilities\Third_Party\FreeRTOSV7.3.0\include;..\function_modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../src/: system_stm32f4xx.c
  group MDK-ARM
    ./: startup_stm32f4xx.s
  group User
    ../src/: main.c stm32f4xx_it.c
  group LwIP
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c def.c timers.c
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../Utilities/Third_Party/lwip-1.4.1/src/netif/: etharp.c
    ../../../../Utilities/Third_Party/lwip-1.4.1/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_i2c.c stm32f4xx_spi.c stm32f4xx_dac.c stm32f4xx_tim.c
  group STM32F4x7_ETH_Driver
    ../../../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group FreeRTOS
    ../../../../Utilities/Third_Party/FreeRTOSV7.3.0/portable/MemMang/: heap_4.c
    ../../../../Utilities/Third_Party/FreeRTOSV7.3.0/: tasks.c croutine.c list.c queue.c
    ../../../../Utilities/Third_Party/FreeRTOSV7.3.0/portable/RVDS/ARM_CM3/: port.c
  group function_modules
    ../function_modules/: board_init.c system_rcc_init.c rs485.c CRC_8.c led.c uart.c ads1255.c direction.c mechanicalcontrol.c sensor_test.c SignalsGeneration.c dma.c malloc.c stmflash.c
target STM324x7I_EVAL (ARM-ADS)
  device: STM32F437II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM324xG_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427X,USE_STM324x7I_EVAL
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\Utilities\STM32_EVAL\STM324x7I_EVAL;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\lwip;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\netif;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\ipv4;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4x7;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4x7\FreeRTOS;..\..\..\..\Utilities\Third_Party\FreeRTOSV7.3.0\portable\RVDS\ARM_CM3;..\..\..\..\Utilities\Third_Party\FreeRTOSV7.3.0\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
